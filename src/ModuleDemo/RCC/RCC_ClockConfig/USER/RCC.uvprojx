# Keil uVision project RCC.uvprojx, settings and files
target RCC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RCC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\..\..\..\Libraries\MH32F10xLib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM;..\..\..\..\Libraries\MH32F10xLib\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c mh32f10x_it.c
    ../../../../Libraries/MH32F10xLib/src/: system_mh32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_mh32f10x.s
  group FWLib
    ../../../../Libraries/MH32F10xLib/src/: misc.c mh32f10x_rcc.c mh32f10x_gpio.c mh32f10x_usart.c
  group Lib
    ../../../../Libraries/MH32F10xLib/lib/: mh.lib
