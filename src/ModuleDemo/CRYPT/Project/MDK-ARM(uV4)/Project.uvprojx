# Keil uVision project Project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\User;..\..\User\cryptlibTest;..\..\..\..\Libraries\MH32F10xLib\inc;..\..\..\..\Libraries\MH32F10xLib\inc\cryptlib;..\..\..\..\Libraries\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --callgraph
  group User
    ../../User/: main.c mh32f10x_it.c
  group MDK-ARM
    ../../../../Libraries/CORE/: startup_mh32f10x.s
  group MHSCPU_Driver
    ../../../../Libraries/MH32F10xLib/src/: misc.c mh32f10x_gpio.c mh32f10x_rcc.c mh32f10x_tim.c mh32f10x_usart.c mh32f10x_trng.c
  group CMSIS
    ../../../../Libraries/MH32F10xLib/src/: system_mh32f10x.c
  group CRYPT_SELF_TEST
    ../../User/cryptlibTest/: debug.c mh_bignum_tool.c aes_self_test.c des_self_test.c sha_self_test.c sm1_self_test.c sm4_self_test.c sm7_self_test.c sm3_self_test.c des_time_test.c sha_time_test.c sm1_time_test.c sm3_time_test.c sm4_time_test.c sm7_time_test.c aes_time_test.c
  group CRYPT_LIB
    ../../../../Libraries/MH32F10xLib/lib/: crypt_lib.lib
target RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,STM32F10X_HD
  c include: ..\..\..\..\Libraries\MH32F103Lib\inc;..\..\..\..\Libraries\MH32F103Lib\inc\cryptlib;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\STM32F10x_FWLib\inc;..\..\User\cryptlibTest;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x20002000 size 0x8000
  memory RVCT9: RAM 0x2000a000 size 0x5000
  link misc: --callgraph
software components: CMSIS:CORE 5.2.0
