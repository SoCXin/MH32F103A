# Keil uVision project USB.uvprojx, settings and files
target USB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: USB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\Libraries\MH32F10xLib\inc;..\SYSTEM\led;..\SYSTEM\delay;..\USER;..\USB\CONFIG;..\USB\MH32_USB-FS-Device_Driver\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\MH32F10xLib\lib;..\..\..\..\ModuleDemo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c mh32f10x_it.c
    ../SYSTEM/delay/: delay.c
  group Startup
    ../../../../Libraries/CORE/: startup_mh32f10x.s
  group StdPeriph_Driver
    ../../../../Libraries/MH32F10xLib/src/: mh32f10x_gpio.c mh32f10x_rcc.c mh32f10x_exti.c mh32f10x_tim.c mh32f10x_usart.c mh32f10x_iwdg.c mh32f10x_wwdg.c mh32f10x_bkp.c mh32f10x_pwr.c mh32f10x_adc.c mh32f10x_dac.c mh32f10x_dma.c mh32f10x_rtc.c mh32f10x_can.c misc.c mh32f10x_flash.c mh32f10x_spi.c
  group CMSIS
    ../../../../Libraries/CORE/: core_cm3.c
    ./: system_mh32f10x.c
  group USB_CORE
    ../USB/MH32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c memory.c scsi_data.c usb_bot.c usb_scsi.c mass_mal.c Internal_Flash.c w25qxx.c bsp_sdio_sdcard.c
  group LIB
    ../../../../Libraries/MH32F10xLib/lib/: mh.lib
